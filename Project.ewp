# IAR project Project.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003K3 STM8S003K3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x200
  General.GenHeapSize: 0x1000
  ICCSTM8.CCDefines: USE_STDPERIPH_DRIVER; STM8S103
  ICCSTM8.CCIncludePath2: C:\Users\Vincent Gijsen\Dropbox\STM8\IAR\Project02\StdPerph\inc; C:\Users\Vincent Gijsen\Dropbox\STM8\IAR\Project02\StdPerph
  ICCSTM8.IccLang: 1
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  ICCSTM8.IccLang: 0
  group (top)
    ./: delay.h LT8900.cpp main.cpp README.md SPI_BitBang.cpp stm8s_conf.h uart.c
    StdPerph/inc/: stm8s.h
  group StdPeripheral
    StdPerph/src/: stm8s_adc1.c stm8s_adc2.c stm8s_awu.c stm8s_beep.c stm8s_can.c stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_i2c.c stm8s_itc.c stm8s_iwdg.c stm8s_rst.c stm8s_spi.c stm8s_tim1.c stm8s_tim2.c stm8s_tim3.c stm8s_tim4.c stm8s_tim5.c stm8s_tim6.c stm8s_uart1.c stm8s_uart2.c stm8s_uart3.c stm8s_uart4.c stm8s_wwdg.c
